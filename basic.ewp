# IAR project basic.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM0G3507 TexasInstruments MSPM0G3507
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __MSPM0G3507__; _UNICODE; UNICODE
  ICCARM.CCDiagSuppress: Pa209,Pe188
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; User_Peripheral; User_Devices; User_Algorithm; User_Application; $MSPM0_SDK_INSTALL_DIR$/source/third_party/CMSIS/Core/Include; $MSPM0_SDK_INSTALL_DIR$/source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$; User_Peripheral; User_Devices; User_Algorithm; User_Application
  ILINK.IlinkOutputFile: basic.out
  ILINK.IlinkIcfFile: mspm0g3507.icf
  ILINK.IlinkExtraOptions: $MSPM0_SDK_INSTALL_DIR$/source/ti/driverlib/lib/iar/m0p/mspm0g1x0x_g3x0x/driverlib.a; -L$MSPM0_SDK_INSTALL_DIR$/source; -L$PROJ_DIR$; --silent
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Minimal_Bringup (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkOutputFile: minimal_bringup.out
  group (top)
    ./: globals.c main.c main.syscfg
  group Examples/minimal_bringup
    examples/minimal_bringup/: main_minimal.c
  group SysConfig Generated Files
    ./: ti_msp_dl_config.c ti_msp_dl_config.h
  group TI_DriverLib/iar
    ./: mspm0g3507.icf
    iar/: startup_mspm0g350x_iar.c
  group TI_DriverLib/ti/driverlib
    ti/driverlib/: dl_adc12.c dl_adc12.h dl_aes.c dl_aes.h dl_aesadv.c dl_aesadv.h dl_common.c dl_common.h dl_comp.c dl_comp.h dl_crc.c dl_crc.h dl_crcp.c dl_crcp.h dl_dac12.c dl_dac12.h dl_dma.c dl_dma.h dl_flashctl.c dl_flashctl.h dl_gpamp.c dl_gpamp.h dl_gpio.c dl_gpio.h dl_i2c.c dl_i2c.h dl_iwdt.c dl_iwdt.h dl_keystorectl.c dl_keystorectl.h dl_lcd.c dl_lcd.h dl_lfss.c dl_lfss.h dl_mathacl.c dl_mathacl.h dl_mcan.c dl_mcan.h dl_opa.c dl_opa.h dl_rtc.c dl_rtc.h dl_rtc_a.c dl_rtc_a.h dl_rtc_b.c dl_rtc_b.h dl_rtc_common.c dl_rtc_common.h dl_scratchpad.c dl_scratchpad.h dl_spi.c dl_spi.h dl_tamperio.c dl_tamperio.h dl_timer.c dl_timer.h dl_timera.c dl_timera.h dl_timerg.c dl_timerg.h dl_trng.c dl_trng.h dl_uart.c dl_uart.h dl_uart_extend.h dl_uart_main.h dl_vref.c dl_vref.h dl_wwdt.c dl_wwdt.h driverlib.h
  group TI_DriverLib/ti/driverlib/m0p
    ti/driverlib/m0p/: dl_core.h dl_factoryregion.c dl_factoryregion.h dl_interrupt.c dl_interrupt.h dl_sysctl.h dl_systick.h
  group TI_DriverLib/ti/driverlib/m0p/sysctl
    ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0c1105_c1106.c dl_sysctl_mspm0c1105_c1106.h dl_sysctl_mspm0c110x.c dl_sysctl_mspm0c110x.h dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0g1x0x_g3x0x.h dl_sysctl_mspm0gx51x.c dl_sysctl_mspm0gx51x.h dl_sysctl_mspm0h321x.c dl_sysctl_mspm0h321x.h dl_sysctl_mspm0l111x.c dl_sysctl_mspm0l111x.h dl_sysctl_mspm0l11xx_l13xx.c dl_sysctl_mspm0l11xx_l13xx.h dl_sysctl_mspm0l122x_l222x.c dl_sysctl_mspm0l122x_l222x.h
  group User_Algorithm
    User_Algorithm/: userlib_pid.c
  group User_Application
    User_Application/: user_ui.c userapp_mcm.c userapp_race.c userapp_race_table.c userapp_state_estimator.c
  group User_Devices
    User_Devices/: userlib_encoder.c userlib_imu.c userlib_lbb.c userlib_lidar.c userlib_modbus.c userlib_motor.c userlib_oemt_an.c userlib_oemt_dg.c userlib_oled.c userlib_servo.c
  group User_Peripheral
    User_Peripheral/: userlib_adc.c userlib_can.c userlib_pwm.c userlib_sys.c userlib_uart.c
